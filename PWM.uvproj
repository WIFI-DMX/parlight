# Keil uVision project PWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: PWM +hex
  c flags: SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\Code;.\drv;..\..\app\drive
  group Source
    ./Code/: main.c Time2.c task_51.c led.c menu.c Pwm.c UART0_mode_3.c IAP_BYTE.c
  group Drv
    ./drv/: menu_fun_seg.c wx_i2c_51.c usart_n76.c Tm1618_n76.c uled_n76.c
  group Common
    ./Common/: Common.c
  group Startup
    ./Startup/: STARTUP.A51
